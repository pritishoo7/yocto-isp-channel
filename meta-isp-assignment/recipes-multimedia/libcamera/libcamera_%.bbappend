EXTRA_OEMESON:append = " -Dpipelines=vimc -Dipas=vimc"
